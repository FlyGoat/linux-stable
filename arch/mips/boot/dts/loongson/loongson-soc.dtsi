// SPDX-License-Identifier: GPL-2.0
/ {
	/*
	 * Loongson-2K have only one node, each node has 2 cores.
	 */
	cpus {
		#address-cells = <1>;
		#size-cells = <0>;

		cpu@0 {
			compatible = "loongson,gs264";
			device_type = "cpu";
			reg = <0x0>;
			next-level-cache = <&scache0>;
		};

		cpu@1 {
			compatible = "loongson,gs264";
			device_type = "cpu";
			reg = <0x1>;
			next-level-cache = <&scache0>;
		};


		scache0: l2-cache0 {
			compatible = "cache";
		};

  memory {
   name = "memory";
   device_type = "memory";
 };

 cpuic: interrupt-controller {
   compatible = "mti,cpu-interrupt-controller";
   interrupt-controller;
   #interrupt-cells = <1>;
 };

 soc {
 		compatible = "ls,nbus", "simple-bus";
 		#address-cells = <1>;
 		#size-cells = <1>;
 		ranges = <0x10000000 0 0x10000000 0x10000000
    0x40000000 0 0x40000000 0x40000000
    0x20000000 0 0x20000000 0x20000000
    0x0d000000 0 0x0d000000 0x02000000>;

 platic: interrupt-controller@1fe11400 {
   compatible = "loongson,ls2k-interrupt-controller";
   interrupt-controller;
   #interrupt-cells = <1>;
   reg = <0x1fe11400 0x40>;
   interrupt-parent = <&cpuic>;
 };


 serial0x@0x1fe00000{
   device_type = "serial";
   compatible = "ns16550";
   reg = <0x1fe00000 0x100>;
   clock-frequency = <125000000>;
   interrupt-parent = <&icu>;
   interrupts = <8>;
 };
